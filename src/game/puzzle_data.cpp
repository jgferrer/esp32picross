#include "game/puzzle_data.h"
#include "config.h"

// Colores RGB565 para los diseños revelados
#ifdef _B
#undef _B
#endif
#define _B  COLOR_GRID_BG
#define _K  0x0000 // Negro
#define _W  0xFFFF // Blanco
#define _R  0xF800 // Rojo brillante
#define _DR 0x9000 // Rojo oscuro
#define _PK 0xFDB4 // Rosa
#define _Y  0xFFE0 // Amarillo
#define _O  0xFD20 // Naranja
#define _G  0x2EA5 // Verde esmeralda
#define _DG 0x0BE2 // Verde oscuro
#ifdef _C
#undef _C
#endif
#define _C  0x07FF // Cian
#define _BL 0x217F // Azul
#define _DB 0x08CD // Azul oscuro
#define _MG 0xF81F // Magenta
#define _PR 0x8115 // Púrpura
#define _BR 0x8A22 // Marrón madera
#define _GY 0x8C71 // Gris
#define _LG 0xD69A // Gris claro
#define _GL 0xFDE0 // Dorado
#define _BE 0xF754 // Beige piel

const Puzzle PUZZLES[TOTAL_PUZZLES] = {
    // ------------------------------------------------------------------------
    // PUZZLE 1: CORAZÓN (5x5)
    // ------------------------------------------------------------------------
    {
        "CORAZON",
        5,
        {
            { 0, 1, 0, 1, 0 },
            { 1, 1, 1, 1, 1 },
            { 1, 1, 1, 1, 1 },
            { 0, 1, 1, 1, 0 },
            { 0, 0, 1, 0, 0 }
        },
        {
            { _B,  _PK, _B,  _R,  _B  },
            { _PK, _W,  _R,  _R,  _DR },
            { _R,  _R,  _R,  _DR, _DR },
            { _B,  _R,  _DR, _DR, _B  },
            { _B,  _B,  _DR, _B,  _B  }
        }
    },

    // ------------------------------------------------------------------------
    // PUZZLE 2: CARITA FELIZ (5x5)
    // ------------------------------------------------------------------------
    {
        "CARITA FELIZ",
        5,
        {
            { 0, 1, 0, 1, 0 },
            { 0, 1, 0, 1, 0 },
            { 0, 0, 0, 0, 0 },
            { 1, 0, 0, 0, 1 },
            { 0, 1, 1, 1, 0 }
        },
        {
            { _B, _K, _B, _K, _B },
            { _B, _K, _B, _K, _B },
            { _B, _B, _B, _B, _B },
            { _O, _B, _B, _B, _O },
            { _B, _R, _R, _R, _B }
        }
    },

    // ------------------------------------------------------------------------
    // PUZZLE 3: NOTA MUSICAL (5x5)
    // ------------------------------------------------------------------------
    {
        "NOTA MUSICAL",
        5,
        {
            { 0, 0, 1, 1, 1 },
            { 0, 0, 1, 0, 1 },
            { 0, 0, 1, 0, 1 },
            { 1, 1, 1, 0, 1 },
            { 1, 1, 1, 0, 1 }
        },
        {
            { _B,  _B,  _C,  _C,  _C },
            { _B,  _B,  _BL, _B,  _C },
            { _B,  _B,  _BL, _B,  _C },
            { _MG, _MG, _BL, _B,  _C },
            { _MG, _MG, _BL, _B,  _BL}
        }
    },

    // ------------------------------------------------------------------------
    // PUZZLE 4: PATITO (5x5)
    // ------------------------------------------------------------------------
    {
        "PATITO",
        5,
        {
            { 0, 1, 1, 0, 0 },
            { 1, 1, 1, 1, 0 },
            { 0, 1, 1, 1, 1 },
            { 0, 1, 1, 1, 1 },
            { 0, 0, 1, 1, 0 }
        },
        {
            { _B, _Y, _Y, _B, _B },
            { _O, _Y, _K, _Y, _B },
            { _B, _Y, _Y, _Y, _Y },
            { _B, _Y, _O, _Y, _Y },
            { _B, _B, _O, _O, _B }
        }
    },

    // ------------------------------------------------------------------------
    // PUZZLE 5: ESPADA CORTA (5x5)
    // ------------------------------------------------------------------------
    {
        "DAGA RETRO",
        5,
        {
            { 0, 0, 1, 0, 0 },
            { 0, 0, 1, 0, 0 },
            { 0, 1, 1, 1, 0 },
            { 0, 0, 1, 0, 0 },
            { 0, 1, 0, 1, 0 }
        },
        {
            { _B, _B, _W,  _B, _B },
            { _B, _B, _C,  _B, _B },
            { _B, _GL,_GL, _GL,_B },
            { _B, _B, _BR, _B, _B },
            { _B, _R, _B,  _R, _B }
        }
    },

    // ------------------------------------------------------------------------
    // PUZZLE 6: SUPER HONGO (10x10)
    // ------------------------------------------------------------------------
    {
        "SUPER HONGO",
        10,
        {
            { 0, 0, 0, 1, 1, 1, 1, 0, 0, 0 },
            { 0, 0, 1, 1, 1, 1, 1, 1, 0, 0 },
            { 0, 1, 1, 1, 1, 1, 1, 1, 1, 0 },
            { 1, 1, 0, 0, 1, 1, 0, 0, 1, 1 },
            { 1, 1, 0, 0, 1, 1, 0, 0, 1, 1 },
            { 1, 1, 1, 1, 1, 1, 1, 1, 1, 1 },
            { 0, 0, 1, 1, 1, 1, 1, 1, 0, 0 },
            { 0, 0, 1, 0, 1, 1, 0, 1, 0, 0 },
            { 0, 0, 1, 0, 1, 1, 0, 1, 0, 0 },
            { 0, 0, 1, 1, 1, 1, 1, 1, 0, 0 }
        },
        {
            { _B, _B, _B, _R, _R, _R, _R, _B, _B, _B },
            { _B, _B, _R, _W, _W, _W, _W, _R, _B, _B },
            { _B, _R, _W, _W, _R, _R, _W, _W, _R, _B },
            { _R, _R, _B, _B, _R, _R, _B, _B, _R, _R },
            { _R, _R, _B, _B, _R, _R, _B, _B, _R, _R },
            { _DR,_DR,_R, _R, _R, _R, _R, _R, _DR,_DR},
            { _B, _B, _BE,_BE,_BE,_BE,_BE,_BE,_B, _B },
            { _B, _B, _BE,_K, _BE,_BE,_K, _BE,_B, _B },
            { _B, _B, _BE,_K, _BE,_BE,_K, _BE,_B, _B },
            { _B, _B, _BE,_BE,_BE,_BE,_BE,_BE,_B, _B }
        }
    },

    // ------------------------------------------------------------------------
    // PUZZLE 7: FANTASMA ARCADE (10x10)
    // ------------------------------------------------------------------------
    {
        "FANTASMITA",
        10,
        {
            { 0, 0, 1, 1, 1, 1, 1, 1, 0, 0 },
            { 0, 1, 1, 1, 1, 1, 1, 1, 1, 0 },
            { 1, 1, 0, 1, 1, 1, 0, 1, 1, 1 },
            { 1, 1, 0, 1, 1, 1, 0, 1, 1, 1 },
            { 1, 1, 1, 1, 1, 1, 1, 1, 1, 1 },
            { 1, 1, 1, 1, 1, 1, 1, 1, 1, 1 },
            { 1, 1, 1, 1, 1, 1, 1, 1, 1, 1 },
            { 1, 1, 1, 1, 1, 1, 1, 1, 1, 1 },
            { 1, 0, 1, 0, 1, 1, 0, 1, 0, 1 },
            { 1, 0, 0, 0, 1, 1, 0, 0, 0, 1 }
        },
        {
            { _B, _B, _C, _C, _C, _C, _C, _C, _B, _B },
            { _B, _C, _C, _C, _C, _C, _C, _C, _C, _B },
            { _C, _W, _BL,_C, _C, _W, _BL,_C, _C, _C },
            { _C, _W, _BL,_C, _C, _W, _BL,_C, _C, _C },
            { _C, _C, _C, _C, _C, _C, _C, _C, _C, _C },
            { _C, _C, _C, _C, _C, _C, _C, _C, _C, _C },
            { _C, _C, _C, _C, _C, _C, _C, _C, _C, _C },
            { _C, _C, _C, _C, _C, _C, _C, _C, _C, _C },
            { _C, _B, _C, _B, _C, _C, _B, _C, _B, _C },
            { _C, _B, _B, _B, _C, _C, _B, _B, _B, _C }
        }
    },

    // ------------------------------------------------------------------------
    // PUZZLE 8: CALAVERA PIRATA (10x10)
    // ------------------------------------------------------------------------
    {
        "CALAVERA",
        10,
        {
            { 0, 0, 1, 1, 1, 1, 1, 1, 0, 0 },
            { 0, 1, 1, 1, 1, 1, 1, 1, 1, 0 },
            { 1, 1, 1, 1, 1, 1, 1, 1, 1, 1 },
            { 1, 1, 0, 0, 1, 1, 0, 0, 1, 1 },
            { 1, 1, 0, 0, 1, 1, 0, 0, 1, 1 },
            { 1, 1, 1, 1, 0, 0, 1, 1, 1, 1 },
            { 0, 1, 1, 1, 1, 1, 1, 1, 1, 0 },
            { 0, 0, 1, 1, 1, 1, 1, 1, 0, 0 },
            { 0, 0, 1, 0, 1, 1, 0, 1, 0, 0 },
            { 0, 0, 1, 1, 1, 1, 1, 1, 0, 0 }
        },
        {
            { _B, _B, _W, _W, _W, _W, _W, _W, _B, _B },
            { _B, _W, _W, _W, _W, _W, _W, _W, _W, _B },
            { _W, _W, _W, _W, _W, _W, _W, _W, _W, _W },
            { _W, _W, _K, _K, _W, _W, _K, _K, _W, _W },
            { _W, _W, _K, _K, _W, _W, _K, _K, _W, _W },
            { _W, _W, _W, _W, _K, _K, _W, _W, _W, _W },
            { _B, _W, _LG,_W, _W, _W, _W, _LG,_W, _B },
            { _B, _B, _W, _W, _W, _W, _W, _W, _B, _B },
            { _B, _B, _W, _K, _W, _W, _K, _W, _B, _B },
            { _B, _B, _W, _W, _W, _W, _W, _W, _B, _B }
        }
    },

    // ------------------------------------------------------------------------
    // PUZZLE 9: COPA DE ORO (10x10)
    // ------------------------------------------------------------------------
    {
        "COPA DE ORO",
        10,
        {
            { 1, 1, 1, 1, 1, 1, 1, 1, 1, 1 },
            { 1, 0, 1, 1, 1, 1, 1, 1, 0, 1 },
            { 1, 0, 1, 1, 1, 1, 1, 1, 0, 1 },
            { 0, 1, 1, 1, 1, 1, 1, 1, 1, 0 },
            { 0, 0, 0, 1, 1, 1, 1, 0, 0, 0 },
            { 0, 0, 0, 0, 1, 1, 0, 0, 0, 0 },
            { 0, 0, 0, 0, 1, 1, 0, 0, 0, 0 },
            { 0, 0, 0, 1, 1, 1, 1, 0, 0, 0 },
            { 0, 0, 1, 1, 1, 1, 1, 1, 0, 0 },
            { 0, 1, 1, 1, 1, 1, 1, 1, 1, 0 }
        },
        {
            { _GL,_GL,_W, _GL,_GL,_GL,_GL,_GL,_GL,_GL},
            { _GL,_B, _W, _GL,_GL,_GL,_GL,_GL,_B, _GL},
            { _GL,_B, _W, _GL,_GL,_GL,_GL,_GL,_B, _GL},
            { _B, _GL,_GL,_GL,_GL,_GL,_GL,_GL,_GL,_B },
            { _B, _B, _B, _GL,_GL,_GL,_GL,_B, _B, _B },
            { _B, _B, _B, _B, _GL,_GL,_B, _B, _B, _B },
            { _B, _B, _B, _B, _GL,_GL,_B, _B, _B, _B },
            { _B, _B, _B, _BR,_BR,_BR,_BR,_B, _B, _B },
            { _B, _B, _BR,_BR,_BR,_BR,_BR,_BR,_B, _B },
            { _B, _BR,_BR,_BR,_BR,_BR,_BR,_BR,_BR,_B }
        }
    },

    // ------------------------------------------------------------------------
    // PUZZLE 10: CONSOLA RETRO (10x10)
    // ------------------------------------------------------------------------
    {
        "CONSOLA RETRO",
        10,
        {
            { 0, 1, 1, 1, 1, 1, 1, 1, 1, 0 },
            { 0, 1, 0, 0, 0, 0, 0, 0, 1, 0 },
            { 0, 1, 0, 1, 1, 1, 1, 0, 1, 0 },
            { 0, 1, 0, 1, 1, 1, 1, 0, 1, 0 },
            { 0, 1, 0, 0, 0, 0, 0, 0, 1, 0 },
            { 0, 1, 1, 1, 1, 1, 1, 1, 1, 0 },
            { 0, 1, 0, 1, 0, 0, 0, 1, 1, 0 },
            { 0, 1, 1, 1, 1, 0, 1, 0, 1, 0 },
            { 0, 1, 0, 1, 0, 0, 0, 0, 1, 0 },
            { 0, 1, 1, 1, 1, 1, 1, 1, 1, 0 }
        },
        {
            { _B, _LG,_LG,_LG,_LG,_LG,_LG,_LG,_LG,_B },
            { _B, _LG,_GY,_GY,_GY,_GY,_GY,_GY,_LG,_B },
            { _B, _LG,_GY,_G, _G, _G, _G, _GY,_LG,_B },
            { _B, _LG,_GY,_DG,_DG,_G, _G, _GY,_LG,_B },
            { _B, _LG,_GY,_GY,_GY,_GY,_GY,_GY,_LG,_B },
            { _B, _LG,_LG,_LG,_LG,_LG,_LG,_LG,_LG,_B },
            { _B, _LG,_B, _K, _B, _B, _B, _MG,_LG,_B },
            { _B, _LG,_K, _K, _K, _B, _MG,_B, _LG,_B },
            { _B, _LG,_B, _K, _B, _B, _B, _B, _LG,_B },
            { _B, _LG,_LG,_LG,_LG,_LG,_LG,_LG,_LG,_B }
        }
    },

    // ------------------------------------------------------------------------
    // PUZZLE 11: CEREZAS (10x10)
    // ------------------------------------------------------------------------
    {
        "CEREZAS",
        10,
        {
            { 0, 0, 0, 0, 0, 0, 0, 1, 1, 0 },
            { 0, 0, 0, 0, 0, 0, 1, 0, 0, 1 },
            { 0, 0, 0, 1, 0, 1, 0, 0, 0, 1 },
            { 0, 0, 0, 1, 1, 0, 0, 0, 0, 0 },
            { 0, 0, 1, 0, 0, 1, 0, 0, 0, 0 },
            { 0, 1, 1, 1, 0, 0, 1, 1, 1, 0 },
            { 1, 1, 1, 1, 1, 0, 1, 1, 1, 1 },
            { 1, 1, 1, 1, 1, 1, 1, 1, 1, 1 },
            { 1, 1, 1, 1, 1, 1, 1, 1, 1, 1 },
            { 0, 1, 1, 1, 0, 0, 1, 1, 1, 0 }
        },
        {
            { _B, _B, _B, _B, _B, _B, _B, _G, _G, _B },
            { _B, _B, _B, _B, _B, _B, _BR,_B, _B, _G },
            { _B, _B, _B, _BR,_B, _BR,_B, _B, _B, _G },
            { _B, _B, _B, _BR,_BR,_B, _B, _B, _B, _B },
            { _B, _B, _BR,_B, _B, _BR,_B, _B, _B, _B },
            { _B, _PK,_R, _R, _B, _B, _PK,_R, _R, _B },
            { _PK,_W, _R, _R, _DR,_B, _PK,_W, _R, _DR},
            { _R, _R, _R, _DR,_DR,_R, _R, _R, _DR,_DR},
            { _R, _DR,_DR,_DR,_DR,_R, _DR,_DR,_DR,_DR},
            { _B, _DR,_DR,_DR,_B, _B, _DR,_DR,_DR,_B }
        }
    },

    // ------------------------------------------------------------------------
    // PUZZLE 12: OVNI ESPACIAL (10x10)
    // ------------------------------------------------------------------------
    {
        "OVNI",
        10,
        {
            { 0, 0, 0, 0, 1, 1, 0, 0, 0, 0 },
            { 0, 0, 0, 1, 1, 1, 1, 0, 0, 0 },
            { 0, 0, 1, 1, 1, 1, 1, 1, 0, 0 },
            { 0, 1, 1, 1, 1, 1, 1, 1, 1, 0 },
            { 1, 1, 1, 1, 1, 1, 1, 1, 1, 1 },
            { 1, 0, 1, 0, 1, 1, 0, 1, 0, 1 },
            { 0, 1, 1, 1, 1, 1, 1, 1, 1, 0 },
            { 0, 0, 0, 1, 0, 0, 1, 0, 0, 0 },
            { 0, 0, 1, 0, 0, 0, 0, 1, 0, 0 },
            { 0, 1, 0, 0, 0, 0, 0, 0, 1, 0 }
        },
        {
            { _B, _B, _B, _B, _C, _C, _B, _B, _B, _B },
            { _B, _B, _B, _C, _G, _G, _C, _B, _B, _B },
            { _B, _B, _C, _W, _C, _C, _C, _C, _B, _B },
            { _B, _LG,_LG,_LG,_LG,_LG,_LG,_LG,_LG,_B },
            { _GY,_GY,_GY,_GY,_GY,_GY,_GY,_GY,_GY,_GY},
            { _Y, _B, _Y, _B, _Y, _Y, _B, _Y, _B, _Y },
            { _B, _GY,_GY,_GY,_GY,_GY,_GY,_GY,_GY,_B },
            { _B, _B, _B, _C, _B, _B, _C, _B, _B, _B },
            { _B, _B, _C, _B, _B, _B, _B, _C, _B, _B },
            { _B, _C, _B, _B, _B, _B, _B, _B, _C, _B }
        }
    },

    // ------------------------------------------------------------------------
    // PUZZLE 13: LLAVE MAESTRA (10x10)
    // ------------------------------------------------------------------------
    {
        "LLAVE DORADA",
        10,
        {
            { 0, 0, 0, 1, 1, 1, 1, 0, 0, 0 },
            { 0, 0, 1, 1, 0, 0, 1, 1, 0, 0 },
            { 0, 0, 1, 1, 0, 0, 1, 1, 0, 0 },
            { 0, 0, 0, 1, 1, 1, 1, 0, 0, 0 },
            { 0, 0, 0, 0, 1, 1, 0, 0, 0, 0 },
            { 0, 0, 0, 0, 1, 1, 0, 0, 0, 0 },
            { 0, 0, 0, 0, 1, 1, 1, 1, 0, 0 },
            { 0, 0, 0, 0, 1, 1, 0, 0, 0, 0 },
            { 0, 0, 0, 0, 1, 1, 1, 0, 0, 0 },
            { 0, 0, 0, 0, 1, 1, 1, 1, 0, 0 }
        },
        {
            { _B, _B, _B, _GL,_GL,_GL,_GL,_B, _B, _B },
            { _B, _B, _GL,_W, _B, _B, _GL,_GL,_B, _B },
            { _B, _B, _GL,_GL,_B, _B, _GL,_GL,_B, _B },
            { _B, _B, _B, _GL,_GL,_GL,_GL,_B, _B, _B },
            { _B, _B, _B, _B, _GL,_GL,_B, _B, _B, _B },
            { _B, _B, _B, _B, _GL,_GL,_B, _B, _B, _B },
            { _B, _B, _B, _B, _GL,_GL,_GL,_GL,_B, _B },
            { _B, _B, _B, _B, _GL,_GL,_B, _B, _B, _B },
            { _B, _B, _B, _B, _GL,_GL,_GL,_B, _B, _B },
            { _B, _B, _B, _B, _GL,_GL,_GL,_GL,_B, _B }
        }
    },

    // ------------------------------------------------------------------------
    // PUZZLE 14: ANCLA MARINERA (10x10)
    // ------------------------------------------------------------------------
    {
        "ANCLA",
        10,
        {
            { 0, 0, 0, 0, 1, 1, 0, 0, 0, 0 },
            { 0, 0, 0, 1, 0, 0, 1, 0, 0, 0 },
            { 0, 0, 0, 0, 1, 1, 0, 0, 0, 0 },
            { 0, 1, 1, 1, 1, 1, 1, 1, 1, 0 },
            { 0, 0, 0, 0, 1, 1, 0, 0, 0, 0 },
            { 0, 0, 0, 0, 1, 1, 0, 0, 0, 0 },
            { 1, 0, 0, 0, 1, 1, 0, 0, 0, 1 },
            { 1, 1, 0, 0, 1, 1, 0, 0, 1, 1 },
            { 0, 1, 1, 1, 1, 1, 1, 1, 1, 0 },
            { 0, 0, 1, 1, 1, 1, 1, 1, 0, 0 }
        },
        {
            { _B, _B, _B, _B, _LG,_LG,_B, _B, _B, _B },
            { _B, _B, _B, _LG,_B, _B, _LG,_B, _B, _B },
            { _B, _B, _B, _B, _LG,_LG,_B, _B, _B, _B },
            { _B, _BR,_BR,_BR,_BR,_BR,_BR,_BR,_BR,_B },
            { _B, _B, _B, _B, _LG,_LG,_B, _B, _B, _B },
            { _B, _B, _B, _B, _LG,_LG,_B, _B, _B, _B },
            { _W, _B, _B, _B, _LG,_LG,_B, _B, _B, _W },
            { _LG,_W, _B, _B, _LG,_LG,_B, _B, _W, _LG},
            { _B, _LG,_LG,_LG,_LG,_LG,_LG,_LG,_LG,_B },
            { _B, _B, _LG,_LG,_LG,_LG,_LG,_LG,_B, _B }
        }
    },

    // ------------------------------------------------------------------------
    // PUZZLE 15: MANZANA (10x10)
    // ------------------------------------------------------------------------
    {
        "MANZANA",
        10,
        {
            { 0, 0, 0, 0, 1, 1, 1, 0, 0, 0 },
            { 0, 0, 0, 0, 0, 1, 0, 0, 0, 0 },
            { 0, 0, 1, 1, 0, 0, 1, 1, 0, 0 },
            { 0, 1, 1, 1, 1, 1, 1, 1, 1, 0 },
            { 1, 1, 1, 1, 1, 1, 1, 1, 1, 1 },
            { 1, 1, 1, 1, 1, 1, 1, 1, 1, 1 },
            { 1, 1, 1, 1, 1, 1, 1, 1, 1, 1 },
            { 1, 1, 1, 1, 1, 1, 1, 1, 1, 1 },
            { 0, 1, 1, 1, 1, 1, 1, 1, 1, 0 },
            { 0, 0, 1, 1, 0, 0, 1, 1, 0, 0 }
        },
        {
            { _B, _B, _B, _B, _G, _G, _G, _B, _B, _B },
            { _B, _B, _B, _B, _B, _BR,_B, _B, _B, _B },
            { _B, _B, _R, _PK,_B, _B, _R, _R, _B, _B },
            { _B, _PK,_W, _R, _R, _R, _R, _R, _DR,_B },
            { _R, _W, _R, _R, _R, _R, _R, _R, _DR,_DR},
            { _R, _R, _R, _R, _R, _R, _R, _R, _DR,_DR},
            { _R, _R, _R, _R, _R, _R, _R, _R, _DR,_DR},
            { _R, _R, _R, _R, _R, _R, _R, _DR,_DR,_DR},
            { _B, _R, _R, _R, _DR,_DR,_DR,_DR,_DR,_B },
            { _B, _B, _DR,_DR,_B, _B, _DR,_DR,_B, _B }
        }
    }
};

void compute_clues(const Puzzle& puzzle,
                   uint8_t row_clues[MAX_GRID_SIZE][MAX_CLUES],
                   uint8_t row_counts[MAX_GRID_SIZE],
                   uint8_t col_clues[MAX_GRID_SIZE][MAX_CLUES],
                   uint8_t col_counts[MAX_GRID_SIZE]) {
    uint8_t s = puzzle.size;

    // 1. Calcular pistas por fila
    for (uint8_t r = 0; r < s; r++) {
        row_counts[r] = 0;
        uint8_t run = 0;
        for (uint8_t c = 0; c < s; c++) {
            if (puzzle.solution[r][c] == 1) {
                run++;
            } else if (run > 0) {
                if (row_counts[r] < MAX_CLUES) {
                    row_clues[r][row_counts[r]++] = run;
                }
                run = 0;
            }
        }
        if (run > 0 && row_counts[r] < MAX_CLUES) {
            row_clues[r][row_counts[r]++] = run;
        }
        if (row_counts[r] == 0) {
            row_clues[r][0] = 0;
            row_counts[r] = 1;
        }
    }

    // 2. Calcular pistas por columna
    for (uint8_t c = 0; c < s; c++) {
        col_counts[c] = 0;
        uint8_t run = 0;
        for (uint8_t r = 0; r < s; r++) {
            if (puzzle.solution[r][c] == 1) {
                run++;
            } else if (run > 0) {
                if (col_counts[c] < MAX_CLUES) {
                    col_clues[c][col_counts[c]++] = run;
                }
                run = 0;
            }
        }
        if (run > 0 && col_counts[c] < MAX_CLUES) {
            col_clues[c][col_counts[c]++] = run;
        }
        if (col_counts[c] == 0) {
            col_clues[c][0] = 0;
            col_counts[c] = 1;
        }
    }
}
